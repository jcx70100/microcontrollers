# Keil uVision project jiaoti.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: jiaoti +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 led_water2.c
    ../../../2015模拟题及答案/我的答案/模拟题/: stc15f2k60s2.h key.h
